# Keil uVision project XXTB.uvproj, settings and files
target CommunicationManagement (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: XXTB
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\source;.\source\DeviceNet;.\source\Module
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./source/CMSIS/: core_cm3.c core_cm3.h LPC17xx.h system_LPC17xx.c system_LPC17xx.h
    ./source/CMSIS/startup/arm/: startup_LPC17xx.s
  group App
    ./source/App/: main.c
  group DeviceNet
    ./source/DeviceNet/: DeviceNet.c DeviceNet.h
  group ReadMe
    ./source/: ReadMe.txt
  group Module
    ./source/Module/: CAN.c CAN.h DeviceIO.c DeviceIO.h rtc.c rtc.h timer.c timer.h RS485.c RS485.h
  group SerialPort
    ./source/DeviceNet/: Action.h CRC16.c CRC16.h RtuFrame.c RtuFrame.h
    ./: Action.c
